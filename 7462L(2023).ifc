Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:02:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:02:58 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\2f976c49-28fc-4377-ba2e-31a0dcf96427\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:02:57 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:02:57 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:02:57 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 7462L Bath and shower faucet, 7462L(2023):7462L Bath and shower faucet:78932
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 152 mm; NominalHeight: 72 mm; NominalWidth: 290 mm
Type - General - Author: BIMStone; BIMObjectName: 7462L(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Thermostatic shower faucet with spout; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - CO2 Emissions (A1-A3): 9.28; CO2 Emissions (A4): 0.33; CO2 Emissions (B7): 1688; CO2 Emissions (C2): 0.02; CO2 Emissions (C3): 0.02; CO2 Emissions (C4): 0.66; CO2 Emissions (D): -5.89; EAN Number: 6414150104473; EN Standard: EN 1111; Noise Class: II (ISO 3822) Oras lab.; RSK Number: 8245065; Sales Package dimensions (LxWxH): 294 x 164 x 83; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7462L; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://www.oras.com/fileadmin/resources/189401_Oras_EPD_Shower_faucet_2022_06_29.pdf; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/188597_7462L_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7462L
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7462L; 3D View: https://static.oras.com/AR/7462L; Catalog Drawing URL: http://static.oras.com/catdrw/7462L; Description: Thermostatic shower faucet with spout; Dimension Drawing URL: http://static.oras.com/dimdrw/7462L; FDV Document URL: http://www.oras.com/datasheet/7462L/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7462L; Group: Bath and shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7462L; Interactive AR View URL: https://static.oras.com/AR/7462L; Manufacturer: Oras; Market: International;Sweden; Mobile Product Information URL: http://mpi.oras.com/7462L; Model: 7462L Bath and shower faucet; Name_en: 7462L Bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7462L; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7462L; Product URL: http://static.oras.com/7462L; Spare-Part Information URL: http://static.oras.com/sp/7462L; Technical DataSheet URL: http://www.oras.com/datasheet/7462L/en; Type Name: 7462L Bath and shower faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Standard aerator; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread; Connection Size: G3/4; Diverter: Turn operated diverter;Integrated into flow control handle; Eco Flow At 300kPa: 0.00565035 m3/s; Flow Rate At 300kPa: 0.0116538 m3/s; Installation Type: Wall mounted; Installation Width: cc150 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Litter filter(s);Non-return valve(s);Thermostatic cartridge for automatic temperature control; Pressure Loss With Flow 02ls: 230000 Pa; Pressure Loss With Flow 03ls: 300000 Pa; Shower Parts: Eco flow control; Spout Projection: 159 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Thermostatic safety stop at 38°C;Temperature fixable; Temperature Adjustments: Safety stop against scalding at 38°C;Temperature preset fixable; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: Temperature and volume control, diverter, EcoFlow control; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7462L(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7462L; Name: 7462L Bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 290x152x72 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0779067 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 90 deg; Volume: 0.00318613 m3
Identity Data - Mark: 33
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7462L(2023): 7462L Bath and shower faucet; Family and Type: 7462L(2023): 7462L Bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7462L(2023): 7462L Bath and shower faucet; Type Id: 7462L(2023): 7462L Bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
